# IAR project Aether.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 NXP MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ24_cm7; FSL_RTOS_FREE_RTOS; SDK_OS_FREE_RTOS; CPU_MKV58F1M0VLQ24; SDK_CORE_ID_CORE0
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: CMSIS; CMSIS_driver; board; drivers; drivers/freertos; freertos/include; freertos/portable; source; startup; utilities; source\Auxiliary; source\Gather; source\Out; source\Process; drivers\AetherDriver
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: CMSIS; CMSIS_driver; board; drivers; drivers/freertos; freertos/include; freertos/portable; source; startup; utilities
  ILINK.IlinkOutputFile: cproject_templates.out
  ILINK.IlinkIcfFile: MKV58F1M0xxx24_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKV58F1M0VLQ24_cm7; FSL_RTOS_FREE_RTOS; SDK_OS_FREE_RTOS; CPU_MKV58F1M0VLQ24; SDK_CORE_ID_CORE0
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MKV58F1M0xxx24_flash.icf
  group board
    board/: board.c board.h clock_config.c clock_config.h peripherals.c peripherals.h pin_mux.c pin_mux.h RTE_Device.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm7.h fsl_device_registers.h MKV58F24.h MKV58F24_features.h mpu_armv7.h system_MKV58F24.c system_MKV58F24.h
  group CMSIS_driver
    CMSIS_driver/: Driver_CAN.h Driver_Common.h Driver_ETH.h Driver_ETH_MAC.h Driver_ETH_PHY.h Driver_Flash.h Driver_I2C.h Driver_MCI.h Driver_NAND.h Driver_SAI.h Driver_SPI.h Driver_USART.h Driver_USB.h Driver_USBD.h Driver_USBH.h
  group drivers
    drivers/: fsl_adc16.c fsl_adc16.h fsl_aoi.c fsl_aoi.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_cmsis.c fsl_dspi_cmsis.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_hsadc.c fsl_hsadc.h fsl_i2c.c fsl_i2c.h fsl_i2c_cmsis.c fsl_i2c_cmsis.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_pwm.c fsl_pwm.h fsl_rcm.c fsl_rcm.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_trng.c fsl_trng.h fsl_uart.c fsl_uart.h fsl_uart_cmsis.c fsl_uart_cmsis.h fsl_uart_edma.c fsl_uart_edma.h fsl_wdog.c fsl_wdog.h
  group drivers/Aether
    drivers/AetherDriver/: AetherDriver_ADC.c AetherDriver_FLASH.c AetherDriver_FTM.c AetherDriver_GPIO.c AetherDriver_KeyBoard.c AetherDriver_LPTMR.c AetherDriver_NRF.c AetherDriver_PIT.c AetherDriver_RingBuff.c AetherDriver_SCCB.c AetherDriver_SoftIIC.c AetherDriver_SPI.c AetherDriver_SuperSonic.c AetherDriver_UART.c AetherDriver_UART_DataAnalysis.c
  group drivers/freertos
    drivers/freertos/: fsl_dspi_freertos.c fsl_dspi_freertos.h fsl_i2c_freertos.c fsl_i2c_freertos.h fsl_uart_freertos.c fsl_uart_freertos.h
  group freertos
    freertos/: FreeRTOS_for_Kinetis_SDK_v2.0.txt
  group freertos/include
    freertos/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h
  group freertos/license
    freertos/license/: license.txt
  group freertos/portable
    freertos/portable/: fsl_tickless_generic.h fsl_tickless_systick.c heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c port.c portasm.s portmacro.h readme.txt
  group freertos/source
    freertos/source/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
  group source
    source/: FreeRTOSConfig.h include.h main.c
  group source/Auxiliary
    source/Auxiliary/: GlobalStructure.h GlobalVars.c GlobalVars.h Init.c
  group source/Gather
    source/Gather/: Camera.c Gyroscope.c InBluetooth.c Inductance.c Speed.c
  group source/Out
    source/Out/: Beep.c Motor.c OutBluetooth.c RGB.c Screen.c Steer.c
  group source/Process
    source/Process/: Controler.c ImageAnalysis.c MagneticAnalysis.c
  group startup
    startup/: startup_MKV58F24.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_notifier.c fsl_notifier.h fsl_shell.c fsl_shell.h fsl_str.c fsl_str.h
